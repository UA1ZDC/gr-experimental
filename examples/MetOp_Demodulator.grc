options:
  parameters:
    author: MB
    generate_options: qt_gui
    id: AHRPT_FY3AB_Airspy_demodulator
    output_language: python
    realtime_scheduling: '1'
    title: MetOp_QPSK_Demodulator+Viterbi decoder
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1704.500000e6
  states: {}
- name: clock_alpha
  id: variable_qtgui_range
  parameters:
    label: Clock Alpha
    min_len: '150'
    start: '1e-3'
    step: '1e-5'
    stop: '10e-3'
    value: '8.7e-3'
  states: {}
- name: pll_alpha
  id: variable_qtgui_range
  parameters:
    label: PLL Alpha
    min_len: '150'
    start: '0.00001'
    step: '0.00001'
    stop: '0.10000'
    value: '0.002'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sample_rate
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 6000e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: (samp_rate*1.0)/(symbol_rate*1.0)
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2.33333333e6
  states: {}
- name: analog_agc_xx_0_0
  id: analog_agc_xx
  parameters:
    gain: 0.5/32768.0
    max_gain: '4000'
    rate: '0.0010e-3'
    reference: '1'
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0_0_0
  id: blocks_file_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.037'
    gain_omega: '0.8'
    mu: '0.9'
    omega: sps
    omega_relative_limit: '0.00015'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_alpha
  states: {}
- name: experimental_deframer_0
  id: experimental_deframer
  parameters: {}
  states: {}
- name: experimental_derand_0
  id: experimental_derand
  parameters: {}
  states: {}
- name: experimental_reedsolomon_0
  id: experimental_reedsolomon
  parameters:
    n: '4'
  states: {}
- name: experimental_viterbi_0_1
  id: experimental_viterbi
  parameters:
    ber_threshold: '0.20'
    fengyun_mode: 'False'
    outsync_after: '5'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"dark red"'
    gui_hint: 0,0,1,1
    marker1: '1'
    name: QPSK
    size: '2048'
    type: complex
    update_time: '0.05'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    gui_hint: 0,2,2,3
    ncols: '1024'
    nrows: '512'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: '361'
    samp_rate: samp_rate
    sym_rate: symbol_rate
    type: fir_filter_ccf
  states: {}

connections:
- [analog_agc_xx_0_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', analog_agc_xx_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', experimental_viterbi_0_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [experimental_deframer_0, '0', experimental_derand_0, '0']
- [experimental_derand_0, '0', experimental_reedsolomon_0, '0']
- [experimental_reedsolomon_0, '0', blocks_file_sink_0_0_0_0_0, '0']
- [experimental_reedsolomon_0, '0', qtgui_time_raster_sink_x_0, '0']
- [experimental_viterbi_0_1, '0', experimental_deframer_0, '0']
- [root_raised_cosine_filter_0, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
